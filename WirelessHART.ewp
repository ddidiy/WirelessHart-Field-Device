# IAR project WirelessHART.ewp, settings and files
configuration AccessPointTR_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MC1322x Freescale MC1322x
  ICCARM.CCDefines: NET_ID=0xAAAA; BACKBONE_SUPPORT; HCF_LOOP_CURRENT_WA; DEBUG_RF_LINK; BOARD_TYPE=1; WIHARTDEV_TYPE=3; IS_MACHINE_LITTLE_ENDIAN; WIRELESS_HART_DEVICE; DEVICE_TYPE=1
  ICCARM.CCDiagSuppress: Pe188
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: WirelessHART_AccessPointTR_vX.Y.Z_NNNN.hex
  postbuild: "$TOOLKIT_DIR$\bin\objcopy.exe" --output-target=binary "$TARGET_BPATH$.out" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: WirelessHART_AccessPointTR_vX.Y.Z_NNNN.out
  ILINK.IlinkIcfFile: MC1322x-RAM-ROM.icf
  ILINK.IlinkProgramEntryLabel: _start_vector_
configuration VN220_FullAPI_UART (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NET_ID=0xAAAA; IS_VN220; HCF_LOOP_CURRENT_WA; LED_CONTROL; DEBUG_RF_LINK; BOARD_TYPE=5; HART_DEV_KIT_REV=4; WIHARTDEV_TYPE=1; IS_MACHINE_LITTLE_ENDIAN; WIRELESS_HART_DEVICE; DEVICE_TYPE=1; SHT1X_MODE=0; UART2_MODE=1; _UAP_TYPE=UAP_TYPE_WHART_API
  OBJCOPY.OOCOutputFile: WirelessHART_VN220_FullAPI_UART_vX.Y.Z_NNNN.hex
  ILINK.IlinkOutputFile: WirelessHART_VN220_FullAPI_UART_vX.Y.Z_NNNN.out
configuration VN220_FullAPI_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NET_ID=0xAAAA; IS_VN220; HCF_LOOP_CURRENT_WA; LED_CONTROL; DEBUG_RF_LINK; BOARD_TYPE=5; HART_DEV_KIT_REV=4; WIHARTDEV_TYPE=1; IS_MACHINE_LITTLE_ENDIAN; WIRELESS_HART_DEVICE; DEVICE_TYPE=1; SHT1X_MODE=0; SPI1_MODE=1; _UAP_TYPE=UAP_TYPE_WHART_API
  OBJCOPY.OOCOutputFile: WirelessHART_VN220_FullAPI_SPI_vX.Y.Z_NNNN.hex
  ILINK.IlinkOutputFile: WirelessHART_VN220_FullAPI_SPI_vX.Y.Z_NNNN.out
  group (top)
    ./: Init-IAR.S
  group arch_sources
    source_files/: adc.c adc_i2c.c adc_loopboard.c asm.c crm.c digitals.c global.c gpio.c itc.c maca.c main.c MC1322x.c spi.c spif_interface.c timers.c uart1.c uart2.c uart_hart.c UT_main.c
  group arch_sources/header
    source_files/: adc.h adc_i2c.h adc_loopboard.h asm.h crm.h digitals.h global.h itc.h maca.h spi.h spif_interface.h system.h timers.h typedef.h uart1.h uart2.h uart_hart.h UT_defines.h
  group CommonAPI
    source_files/CommonAPI/: Common_API.c Common_API.h DAQ_Comm.c DAQ_Comm.h RadioApi.h
  group libs
    libs/: LLC.a MC1322x.a
  group Sensors
    source_files/Sensors/: SHT1x.c SHT1x.h
  group WiredHART_sources
    source_files/WiredHART/: DataLinkLayer.c
    source_files/WiredHart/: DataLinkLayer.h options.h
  group WirelessHART_sources
    source_files/WirelessHart/: app_cmdreq.c app_cmdresp.c app_layer.c apphart.c datalink_layer.c datalink_layer_dm.c drm.c network_layer.c network_layer_dm.c ParseComposeCommand.c ParseComposeCommandTables.c phy_layer.c provision.c transport_layer.c transport_layer_dm.c uap.c uap_data.c uart_link.c
  group WirelessHART_sources/CommonStack_sources/Binarization
    source_files/WirelessHart/ApplicationLayer/Binarization/: CommonPracticeCommands.h DataLinkLayerCommands.h DeviceSpecificCommands.h DeviceSpecificWirelessOnlyCommands.h GatewayCommands.h NetworkLayerCommands.h PhysicalLayerCommands.h UniversalCommands.h WirelessApplicationCommands.h WirelessNetworkManagerCommands.h
  group WirelessHART_sources/CommonStack_sources/Binarization/CommonPracticeCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/CommonPracticeCommands/: C033_ReadDeviceVariables.c C033_ReadDeviceVariables.h C034_WritePrimaryVariableDampingValue.c C034_WritePrimaryVariableDampingValue.h C035_WritePrimaryVariableRangeValues.c C035_WritePrimaryVariableRangeValues.h C036_SetPrimaryVariableUpperRangeValue.c C036_SetPrimaryVariableUpperRangeValue.h C037_SetPrimaryVariableLowerRangeValue.c C037_SetPrimaryVariableLowerRangeValue.h C040_EnterExitFixedCurrentMode.c C040_EnterExitFixedCurrentMode.h C041_PerformSelfTest.c C041_PerformSelfTest.h C042_PerformDeviceReset.c C042_PerformDeviceReset.h C043_SetPrimaryVariableZero.c C043_SetPrimaryVariableZero.h C044_WritePrimaryVariableUnits.c C044_WritePrimaryVariableUnits.h C045_TrimLoopCurrentZero.c C045_TrimLoopCurrentZero.h C046_TrimLoopCurrentGain.c C046_TrimLoopCurrentGain.h C047_WritePrimaryVariableTransferFunction.c C047_WritePrimaryVariableTransferFunction.h C049_WritePrimaryVariableTransducerSerialNumber.c C049_WritePrimaryVariableTransducerSerialNumber.h C050_ReadDynamicVariableAssignments.c C050_ReadDynamicVariableAssignments.h C051_WriteDynamicVariableAssignments.c C051_WriteDynamicVariableAssignments.h C052_SetDeviceVariableZero.c C052_SetDeviceVariableZero.h C053_WriteDeviceVariableUnits.c C053_WriteDeviceVariableUnits.h C054_ReadDeviceVariableInformation.c C054_ReadDeviceVariableInformation.h C055_WriteDeviceVariableDampingValue.c C055_WriteDeviceVariableDampingValue.h C056_WriteDeviceVariableTransducerSerialNo.c C056_WriteDeviceVariableTransducerSerialNo.h C059_WriteNumberOfResponsePreambles.c C059_WriteNumberOfResponsePreambles.h C060_ReadAnalogChannelAndPercentOfRange.c C060_ReadAnalogChannelAndPercentOfRange.h C062_ReadAnalogChannels.c C062_ReadAnalogChannels.h C063_ReadAnalogChannelInformation.c C063_ReadAnalogChannelInformation.h C064_WriteAnalogChannelAdditionalDampingValue.c C064_WriteAnalogChannelAdditionalDampingValue.h C065_WriteAnalogChannelRangeValues.c C065_WriteAnalogChannelRangeValues.h C066_EnterExitFixedAnalogChannelMode.c C066_EnterExitFixedAnalogChannelMode.h C067_TrimAnalogChannelZero.c C067_TrimAnalogChannelZero.h C068_TrimAnalogChannelGain.c C068_TrimAnalogChannelGain.h C069_WriteAnalogChannelTransferFunction.c C069_WriteAnalogChannelTransferFunction.h C070_ReadAnalogChannelEndpointValues.c C070_ReadAnalogChannelEndpointValues.h C071_LockDevice.c C071_LockDevice.h C072_Squawk.c C072_Squawk.h C073_FindDevice.c C073_FindDevice.h C074_ReadIOSystemCapabilities.c C074_ReadIOSystemCapabilities.h C075_PollSubDevice.c C075_PollSubDevice.h C076_ReadLockDeviceState.c C076_ReadLockDeviceState.h C077_SendCommandToSubDevice.c C077_SendCommandToSubDevice.h C078_ReadAggregatedCommands.c C078_ReadAggregatedCommands.h C079_WriteDeviceVariable.c C079_WriteDeviceVariable.h C080_ReadDeviceVariableTrimPoints.c C080_ReadDeviceVariableTrimPoints.h C081_ReadDeviceVariableTrimGuidelines.c C081_ReadDeviceVariableTrimGuidelines.h C082_WriteDeviceVariableTrimPoint.c C082_WriteDeviceVariableTrimPoint.h C083_ResetDeviceVariableTrim.c C083_ResetDeviceVariableTrim.h C084_ReadSubDeviceIdentitySummary.c C084_ReadSubDeviceIdentitySummary.h C085_ReadIOChannelStatistics.c C085_ReadIOChannelStatistics.h C086_ReadSubDeviceStatistics.c C086_ReadSubDeviceStatistics.h C087_WriteIOSystemMasterMode.c C087_WriteIOSystemMasterMode.h C088_WriteIOSystemRetryCount.c C088_WriteIOSystemRetryCount.h C089_SetRealTimeClock.c C089_SetRealTimeClock.h C090_ReadRealTimeClock.c C090_ReadRealTimeClock.h C091_ReadTrendConfiguration.c C091_ReadTrendConfiguration.h C092_WriteTrendConfiguration.c C092_WriteTrendConfiguration.h C093_ReadTrend.c C093_ReadTrend.h C094_ReadIOSystemClientSideCommunicationStatistics.c C094_ReadIOSystemClientSideCommunicationStatistics.h C095_ReadDeviceCommunicationsStatistics.c C095_ReadDeviceCommunicationsStatistics.h C096_ReadSynchronousAction.c C096_ReadSynchronousAction.h C097_ConfigureSynchronousAction.c C097_ConfigureSynchronousAction.h C098_ReadCommandAction.c C098_ReadCommandAction.h C099_ConfigureCommandAction.c C099_ConfigureCommandAction.h C101_ReadSubDeviceToBurstMessageMap.c C101_ReadSubDeviceToBurstMessageMap.h C102_MapSubDeviceToBurstMessage.c C102_MapSubDeviceToBurstMessage.h C103_WriteBurstPeriod.c C103_WriteBurstPeriod.h C104_WriteBurstTrigger.c C104_WriteBurstTrigger.h C105_ReadBurstModeConfiguration.c C105_ReadBurstModeConfiguration.h C106_FlushDelayedResponses.c C106_FlushDelayedResponses.h C107_WriteBurstDeviceVariables.c C107_WriteBurstDeviceVariables.h C108_WriteBurstModeCommandNumber.c C108_WriteBurstModeCommandNumber.h C109_BurstModeControl.c C109_BurstModeControl.h C113_CatchDeviceVariable.c C113_CatchDeviceVariable.h C114_ReadCaughtDeviceVariable.c C114_ReadCaughtDeviceVariable.h C115_ReadEventNotificationSummary.c C115_ReadEventNotificationSummary.h C116_WriteEventNotificationBitMask.c C116_WriteEventNotificationBitMask.h C117_WriteEventNotificationTiming.c C117_WriteEventNotificationTiming.h C118_EventNotificationControl.c C118_EventNotificationControl.h C119_AcknowledgeEventNotification.c C119_AcknowledgeEventNotification.h C512_ReadCountryCode.c C512_ReadCountryCode.h C513_WriteCountryCode.c C513_WriteCountryCode.h
  group WirelessHART_sources/CommonStack_sources/Binarization/DataLinkLayerCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/DataLinkLayerCommands/: C773_WriteNetworkId.c C773_WriteNetworkId.h C774_ReadNetworkId.c C774_ReadNetworkId.h C775_WriteNetworkTag.c C775_WriteNetworkTag.h C776_ReadNetworkTag.c C776_ReadNetworkTag.h C781_ReadDeviceNicknameAddress.c C781_ReadDeviceNicknameAddress.h C783_ReadSuperframeList.c C783_ReadSuperframeList.h C784_ReadLinkList.c C784_ReadLinkList.h C785_ReadGraphList.c C785_ReadGraphList.h C786_ReadNeighborPropertyFlag.c C786_ReadNeighborPropertyFlag.h C787_ReportNeighborSignalLevels.c C787_ReportNeighborSignalLevels.h C788_AlarmPathDown.c C788_AlarmPathDown.h C795_WriteTimerInterval.c C795_WriteTimerInterval.h C796_ReadTimerInterval.c C796_ReadTimerInterval.h C806_ReadHandheldSuperframe.c C806_ReadHandheldSuperframe.h C807_RequestHandheldSuperframeMode.c C807_RequestHandheldSuperframeMode.h C810_ReadJoinPriority.c C810_ReadJoinPriority.h C811_WriteJoinPriority.c C811_WriteJoinPriority.h C812_ReadPacketReceivePriority.c C812_ReadPacketReceivePriority.h C813_WritePacketReceivePriority.c C813_WritePacketReceivePriority.h C819_ReadBackOffExponent.c C819_ReadBackOffExponent.h C820_WriteBackOffExponent.c C820_WriteBackOffExponent.h
  group WirelessHART_sources/CommonStack_sources/Binarization/DeviceSpecificCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/DeviceSpecificCommands/: C133_ReadFirmwareVersion.c C133_ReadFirmwareVersion.h
  group WirelessHART_sources/CommonStack_sources/Binarization/DeviceSpecificWirelessOnlyCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/DeviceSpecificWirelessOnlyCommands/: C64512_ReadWirelessModuleRevision.c C64512_ReadWirelessModuleRevision.h
  group WirelessHART_sources/CommonStack_sources/Binarization/GatewayCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/GatewayCommands/: C832_ReadNetworkDeviceIdentity.c C832_ReadNetworkDeviceIdentity.h C833_ReadNetworkDeviceNeighbourHealth.c C833_ReadNetworkDeviceNeighbourHealth.h C834_ReadNetworkTopologyInformation.c C834_ReadNetworkTopologyInformation.h C835_ReadBurstMessageList.c C835_ReadBurstMessageList.h C836_FlushCacheResponses.c C836_FlushCacheResponses.h C837_WriteUpdateNotificationBitMask.c C837_WriteUpdateNotificationBitMask.h C838_ReadUpdateNotificationBitMask.c C838_ReadUpdateNotificationBitMask.h C839_ChangeNotification.c C839_ChangeNotification.h C840_ReadDeviceStatistics.c C840_ReadDeviceStatistics.h C841_ReadNetworkDeviceIdentityByNickname.c C841_ReadNetworkDeviceIdentityByNickname.h C842_WriteDeviceSchedulingFlags.c C842_WriteDeviceSchedulingFlags.h C843_ReadDeviceSchedulingFlags.c C843_ReadDeviceSchedulingFlags.h C844_ReadNetworkConstraints.c C844_ReadNetworkConstraints.h C845_WriteNetworkConstraints.c C845_WriteNetworkConstraints.h
  group WirelessHART_sources/CommonStack_sources/Binarization/NetworkLayerCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/NetworkLayerCommands/: C768_WriteJoinKey.c C768_WriteJoinKey.h C769_ReadJoinStatus.c C769_ReadJoinStatus.h C770_RequestActiveAdvertise.c C770_RequestActiveAdvertise.h C771_ForceJoin.c C771_ForceJoin.h C772_ReadJoinModeConfiguration.c C772_ReadJoinModeConfiguration.h C782_ReadSessionEntries.c C782_ReadSessionEntries.h C789_AlarmSourceRouteFailed.c C789_AlarmSourceRouteFailed.h C790_AlarmGraphRouteFailed.c C790_AlarmGraphRouteFailed.h C791_AlarmTransportLayerFailed.c C791_AlarmTransportLayerFailed.h C799_RequestService.c C799_RequestService.h C800_ReadServiceList.c C800_ReadServiceList.h C801_DeleteService.c C801_DeleteService.h C802_ReadRouteList.c C802_ReadRouteList.h C803_ReadSourceRoute.c C803_ReadSourceRoute.h C808_ReadTimeToLive.c C808_ReadTimeToLive.h C809_WriteTimeToLive.c C809_WriteTimeToLive.h C814_ReadDeviceListEntries.c C814_ReadDeviceListEntries.h C815_AddDeviceListTableEntry.c C815_AddDeviceListTableEntry.h C816_DeleteDeviceListTableEntry.c C816_DeleteDeviceListTableEntry.h C817_ReadChannelBlacklist.c C817_ReadChannelBlacklist.h C818_WriteChannelBlacklist.c C818_WriteChannelBlacklist.h C821_WriteNetworkAccessMode.c C821_WriteNetworkAccessMode.h C822_ReadNetworkAccessMode.c C822_ReadNetworkAccessMode.h C823_RequestSession.c C823_RequestSession.h
  group WirelessHART_sources/CommonStack_sources/Binarization/PhysicalLayerCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/PhysicalLayerCommands/: C797_WriteRadioPower.c C797_WriteRadioPower.h C798_ReadRadioPower.c C798_ReadRadioPower.h C804_ReadRadioCCAMode.c C804_ReadRadioCCAMode.h C805_WriteRadioCCAMode.c C805_WriteRadioCCAMode.h
  group WirelessHART_sources/CommonStack_sources/Binarization/UniversalCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/UniversalCommands/: C000_ReadUniqueIdentifier.c C000_ReadUniqueIdentifier.h C001_ReadPrimaryVariable.c C001_ReadPrimaryVariable.h C002_ReadLoopCurrentAndPercentOfRange.c C002_ReadLoopCurrentAndPercentOfRange.h C003_ReadDynamicVariablesAndLoopCurrent.c C003_ReadDynamicVariablesAndLoopCurrent.h C006_WritePollingAddress.c C006_WritePollingAddress.h C007_ReadLoopConfiguration.c C007_ReadLoopConfiguration.h C008_ReadDynamicVariableClassifications.c C008_ReadDynamicVariableClassifications.h C009_ReadDeviceVariablesWithStatus.c C009_ReadDeviceVariablesWithStatus.h C011_ReadUniqueIdentifierAssociatedWithTag.c C011_ReadUniqueIdentifierAssociatedWithTag.h C012_ReadMessage.c C012_ReadMessage.h C013_ReadTagDescriptorDate.c C013_ReadTagDescriptorDate.h C014_ReadPrimaryVariableTransducerInformation.c C014_ReadPrimaryVariableTransducerInformation.h C015_ReadDeviceInformation.c C015_ReadDeviceInformation.h C016_ReadFinalAssemblyNumber.c C016_ReadFinalAssemblyNumber.h C017_WriteMessage.c C017_WriteMessage.h C018_WriteTagDescriptorDate.c C018_WriteTagDescriptorDate.h C019_WriteFinalAssemblyNumber.c C019_WriteFinalAssemblyNumber.h C020_ReadLongTag.c C020_ReadLongTag.h C021_ReadUniqueIdentifierAssociatedWithLongTag.c C021_ReadUniqueIdentifierAssociatedWithLongTag.h C022_WriteLongTag.c C022_WriteLongTag.h C038_ResetConfigurationChangedFlag.c C038_ResetConfigurationChangedFlag.h C048_ReadAdditionalDeviceStatus.c C048_ReadAdditionalDeviceStatus.h
  group WirelessHART_sources/CommonStack_sources/Binarization/WirelessApplicationCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/WirelessApplicationCommands/: C777_ReadWirelessDeviceInformation.c C777_ReadWirelessDeviceInformation.h C778_ReadBatteryLife.c C778_ReadBatteryLife.h C779_ReportDeviceHealth.c C779_ReportDeviceHealth.h C780_ReportNeighborHealthList.c C780_ReportNeighborHealthList.h C793_WriteUTCTime.c C793_WriteUTCTime.h C794_ReadUTCTime.c C794_ReadUTCTime.h
  group WirelessHART_sources/CommonStack_sources/Binarization/WirelessNetworkManagerCommands
    source_files/WirelessHart/ApplicationLayer/Binarization/WirelessNetworkManagerCommands/: C960_DisconnectDevice.c C960_DisconnectDevice.h C961_WriteNetworkKey.c C961_WriteNetworkKey.h C962_WriteDeviceNicknameAddress.c C962_WriteDeviceNicknameAddress.h C963_WriteSession.c C963_WriteSession.h C964_DeleteSession.c C964_DeleteSession.h C965_WriteSuperframe.c C965_WriteSuperframe.h C966_DeleteSuperframe.c C966_DeleteSuperframe.h C967_WriteLink.c C967_WriteLink.h C968_DeleteLink.c C968_DeleteLink.h C969_WriteGraphNeighbourPair.c C969_WriteGraphNeighbourPair.h C970_DeleteGraphConnection.c C970_DeleteGraphConnection.h C971_WriteNeighbourPropertyFlag.c C971_WriteNeighbourPropertyFlag.h C972_SuspendDevices.c C972_SuspendDevices.h C973_WriteService.c C973_WriteService.h C974_WriteRoute.c C974_WriteRoute.h C975_DeleteRoute.c C975_DeleteRoute.h C976_WriteSourceRoute.c C976_WriteSourceRoute.h C977_DeleteSourceRoute.c C977_DeleteSourceRoute.h
  group WirelessHART_sources/CommonStack_sources/Model
    source_files/WirelessHART/ApplicationLayer/Model/: CommonPracticeCommands.h CommonResponseCode.h UniversalCommands.h
    source_files/WirelessHart/ApplicationLayer/Model/: CommonTables.h DataLinkLayerCommands.h DeviceSpecificCommands.h DeviceSpecificWirelessOnlyCommands.h GatewayCommands.h NetworkLayerCommands.h PhysicalLayerCommands.h WirelessApplicationCommands.h WirelessNetworkManagerCommands.h
  group WirelessHART_sources/CommonStack_sources/Util
    source_files/WirelessHart/util/: Binarization.c Binarization.h ByteOrder4Int.h
    source_files/WirelessHART/util/: WirelessStackTypes.h
  group WirelessHART_sources/header
    source_files/WirelessHart/: app_cmdreq.h app_cmdresp.h app_layer.h apphart.h CommandTables_AccessPoint.h CommandTables_All.h CommandTables_FieldDevice.h config.h datalink_layer_dm.h drm.h network_layer.h network_layer_dm.h ParseComposeCommand.h ParseComposeCommandTables.h provision.h tmr_util.h transport_layer.h transport_layer_dm.h uart_link.h
    source_files/WirelessHART/: datalink_layer.h phy_layer.h uap.h uap_data.h
